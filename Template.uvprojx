# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm_compiler_v5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe --bin -o .\Obj\Template.bin  .\Obj\Template.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\HARWARE\beep;.\HARWARE\smg;.\HARWARE\key;.\HARWARE\exti;.\HARWARE\time;.\HARWARE\pwm;.\freertos;.\freertos\inc;.\freertos\port;.\HARDWARE\led;.\HARDWARE\lcd;.\APP;.\HARDWARE\w25q128
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c sys.c delay.c
  group Startup
    ./: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/: Display.c Display.h start_task.c start_task.h State.c State.h Flash.c Flash.h
  group Public
    ./Public/: system.c usart.c
  group FreeRTOS
    ./freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
    ./freertos/port/: port.c portmacro.h
    ./freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./freertos/: FreeRTOSConfig.h
  group HARDWARE
    ./HARDWARE/led/: led.c led.h
    ./HARDWARE/lcd/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h
    ./HARDWARE/w25q128/: driver_w25qxx.c driver_w25qxx_interface.c driver_w25qxx.h driver_w25qxx_interface.h driver_w25qxx_read_test.c driver_w25qxx_read_test.h driver_w25qxx_register_test.c driver_w25qxx_register_test.h
